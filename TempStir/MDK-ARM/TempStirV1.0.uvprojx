# Keil uVision project TempStirV1.0.uvprojx, settings and files
target TempStirV1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: TempStirV1_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,NDEBUG
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../MDK-ARM/freertos;../MDK-ARM/freertos/Source/include;../MDK-ARM/freertos/Source/portable/RVDS/ARM_CM3;../MDK-ARM/User/App;../MDK-ARM/User/Int;../MDK-ARM/User/Dri;../MDK-ARM/User/Utils;../MDK-ARM/User/Menu;../MDK-ARM/free_modbus/modbus/include;../MDK-ARM/free_modbus/modbus/rtu;../MDK-ARM/free_modbus/port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../MDK-ARM/freertos/Source/portable/RVDS/ARM_CM3/: port.c
    ../MDK-ARM/freertos/Source/portable/MemMang/: heap_4.c
    ./freertos/: FreeRTOSConfig.h
    ./freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group App
    ./User/App/: app_main.c app_main.h app_fan.c app_fan.h app_modbus.c app_modbus.h app_comm.c app_comm.h app_ble.c app_ble.h app_fault.c app_fault.h app_imu.c app_imu.h app_tune.c app_tune.h app_temp.c app_temp.h app_heat.c app_heat.h app_motor.c app_motor.h app_store.c app_store.h app_rtc.c app_rtc.h
  group Int
    ./User/Int/: int_bsp_i2c1.c int_bsp_i2c1.h int_bsp_i2c2.c int_bsp_i2c2.h int_bsp_pins.h int_gpio.c int_gpio.h int_key.c int_key.h int_adc.c int_adc.h int_spi.c int_spi.h int_tim.c int_tim.h
  group Dri
    ./User/Dri/: dri_ble.c dri_ble.h dri_buzzer.c dri_buzzer.h dri_ds3231.c dri_ds3231.h dri_fan.c dri_fan.h dri_lsm6dsm.c dri_lsm6dsm.h dri_m24c02.c dri_m24c02.h dri_ssd1315.c dri_ssd1315.h
  group Utils
    ./User/Utils/: utils_pid.c utils_pid.h
  group Menu
    ./User/Menu/: menu_ui.c menu_ui.h
  group free_modbus
    ./free_modbus/modbus/: mb.c
    ./free_modbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./free_modbus/modbus/rtu/: mbcrc.c mbrtu.c mbcrc.h mbrtu.h
    ./free_modbus/port/: portevent.c portserial.c porttimer.c port.h app_freemodbus_port.h
    ./free_modbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
software components: CMSIS:CORE 4.3.0
